# Keil uVision project Terminal.uvprojx, settings and files
target Terminal (6140000::V6.14::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Terminal_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,_RTE_,STM32F407xx,HSE_VALUE=25000000,TERMINAL_USE_STM,CMSIS_RTOS2,USE_FULL_ASSERT=1,TERMINAL_DEBUG
  c include: ../Inc;..\LAN;..\USB_CDC;..\..\..\Filling_Station\Filling_Station;..\Src;..\Terminal_MSP;../FLASH;..\MODBUS;..\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: freertos_handlers.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.cpp
  group LAN
    ../LAN/: TCP_Client.cpp TCP_Client.h
  group Terminal
    ../../../Filling_Station/Filling_Station/Terminal/: Bill_Acceptor.cpp Bill_Acceptor.h Core.cpp Core.h Display.cpp Display.h Hopper.cpp Hopper.h Terminal.h Terminal.cpp Tamplates.h
  group Terminal_MSP
    ../Terminal_MSP/: Bill_Acceptor_MSP.cpp Bill_Acceptor_MSP.h Hopper_1_MSP.cpp Hopper_1_MSP.h Hopper_2_MSP.cpp Hopper_2_MSP.h Terminal_MSP.cpp Terminal_MSP.h Buttons_MSP.cpp Buttons_MSP.h Hoppers_MSP.cpp Hoppers_MSP.h
  group MODBUS
    ../MODBUS/: Modbus_CRC.c Modbus_CRC.h
  group RTC
    ../RTC/: Calendar.h Calendar.cpp
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: Terminal_Release +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,_RTE_,STM32F407xx,HSE_VALUE=25000000,TERMINAL_USE_STM,CMSIS_RTOS2,TERMINAL_RELEASE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.12.0, Network:Interface:ETH 7.12.0, Network:Socket:TCP 7.12.0, Network:Socket:UDP 7.12.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:USART 2.12, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:ETH 1.7.6, Device:STM32Cube HAL:Flash 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:RTC 1.7.6, Device:STM32Cube HAL:TIM 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
